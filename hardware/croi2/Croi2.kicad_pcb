# Repository ULAS-HiPR/Ogma2 (continued)

## KiCad design hardware/croi2/Croi2.kicad_pcb (continued)

Schematic: 03hg-sensor.kicad_sch, HG / ADXL375BCCZ / independent SPI and power

Parts:
C3302: 1u 16V X7R; C_0603_1608Metric
C3307: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
C3308: 2.2u 16V X7R; C_0603_1608Metric
R3301: 47R 1%; R_0402_1005Metric; MPN RC0402FR-0747RL; LCSC C137973
R3305: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
R3307, R3308: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
U3304: ADXL375BCCZ; MPN ADXL375BCCZ

Connections:
FLIGHT_3V3: R3301.1, R3305.1; also elsewhere on the board
GND: C3302.2, C3307.2, C3308.2, U3304.2 (GND_[2,4,5,11]), U3304.4, U3304.5, U3304.11; also elsewhere on the board
HG_3V3: C3302.1, C3307.1, C3308.1, R3301.2, U3304.1 (SUPPLY_[1,3,6]), U3304.3, U3304.6
HG_INT1: U3304.8 (INT1); also elsewhere on the board
HG_MISO: U3304.12 (SDO_ALT_ADDRESS); also elsewhere on the board
HG_MOSI: R3308.1; also elsewhere on the board
HG_MOSI_DAMP: R3308.2, U3304.13 (SDA_SDI_SDIO)
HG_NCS: R3305.2, U3304.7 (CS); also elsewhere on the board
HG_SCK: R3307.1; also elsewhere on the board
HG_SCK_DAMP: R3307.2, U3304.14 (SCL_SCLK)

Notes on the sheet:
No switches or isolators (D-6.6). Firmware parks a dead sensor's bus pins so the MCU cannot back-power it through the 22 ohm damping (D-2Nov.3). Pull-ups go to FLIGHT_3V3.
HG / ADXL375BCCZ / INDEPENDENT SPI AND POWER
What this does: Measures acceleration beyond the low-g IMUs' range, using the ADXL375. Connects to: Flight MCU SPI and data-ready pins -> this high-g sensor. Fed from FLIGHT_3V3 through R3301, a 47 ohm link (D-6.6, D-2Nov.3).
2 FLIGHT-TO-SENSOR SPI
1 SUPPLY LINK

Schematic: 02comms-reset-debug.kicad_sch, COMMS / supervised reset / independent SWD

Parts:
C4201, C4202, C4203: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
J4201: TC2030-NL-FP; MPN TC2030-NL-FP
R4201, R4202, R4203: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
TP23: GND; TestPoint_Keystone_5010-5014_Multipurpose; MPN 5011; LCSC C238127
TP24: COMMS_BOOT0; TestPoint_Pad_D1.0mm
U4201: TPS3808G33DBVR; MPN TPS3808G33DBVR

Connections:
COMMS_3V3: C4201.1, C4202.1, J4201.1, R4201.1, R4202.1, U4201.5 (SUPPLY_[5,6]), U4201.6; also elsewhere on the board
COMMS_BOOT0: R4203.1, TP24.1 (1_1); also elsewhere on the board
COMMS_MR_N: R4202.2, U4201.3 (~MR); also elsewhere on the board
COMMS_NRST: C4203.1, J4201.3, R4201.2, U4201.1 (~RESET); also elsewhere on the board
COMMS_SWCLK: J4201.4; also elsewhere on the board
COMMS_SWDIO: J4201.2; also elsewhere on the board
COMMS_SWO: J4201.6; also elsewhere on the board
GND: C4201.2, C4202.2, C4203.2, J4201.5, R4203.2, TP23.1 (1_1), U4201.2 (GND); also elsewhere on the board

Notes on the sheet:
COMMS / SUPERVISED RESET / INDEPENDENT SWD
MR and NRST are different nets. Supervisor output resets the MCU; flight reset request reaches MR through the powered-off boundary.
What this does: Resets the comms MCU cleanly and provides its own programming/debug connection. Connects to: COMMS_3V3 and flight reset request through 04b -> supervisor -> U401. The flight and comms reset wires are separate.
Boot pull-down and Tag-Connect pins are visible. Firmware ownership, MCU allocations, watchdog timing and reset policy are unchanged.

Schematic: 03-sensors-storage.kicad_sch, Fixed log / 256 MiB quad-SPI NOR

Parts:
C3603: 4.7u 16V X7R; C_0603_1608Metric
C3604, C3605, C3606: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
R3605, R3606, R3607, R3608, R3610: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
R3609: 22R; R_0402_1005Metric; MPN 0402WGF220JTCE; LCSC C25092
U3604: MX66L2G45GMI00; MPN MX66L2G45GMI00

Connections:
FLIGHT_3V3: C3603.1, C3604.1, C3605.1, C3606.1, R3605.1, R3606.1, R3607.1, R3608.1, R3610.1, U3604.2 (VCC); also elsewhere on the board
GND: C3603.2, C3604.2, C3605.2, C3606.2, U3604.10 (GND); also elsewhere on the board
NOR_CLK: R3609.1; also elsewhere on the board
NOR_CLK_DAMP: R3609.2, U3604.16 (SCLK)
NOR_IO0: U3604.15 (SI_SIO0); also elsewhere on the board
NOR_IO1: U3604.8 (SO_SIO1); also elsewhere on the board
NOR_IO2: R3607.2, U3604.9 (WP_N_SIO2); also elsewhere on the board
NOR_IO3: R3608.2, U3604.1 (NC_SIO3); also elsewhere on the board
NOR_NCS: R3605.2, U3604.7 (CS_N); also elsewhere on the board
NOR_RESET_REQUEST: R3606.2, R3610.2, U3604.3 (RESET_N); also elsewhere on the board

Notes on the sheet:
All four IO lines are bidirectional. DNU pins stay untouched. The unused switch channel stays disconnected.
100k gives ~0.29 A typical limiting. Verify min/max current limit, startup and partial-rail injection on first PCBA.
FIXED LOG / 256 MIB QUAD-SPI NOR
Pre-erase while disarmed. Start quad-SPI at 16 MHz. No XIP or in-flight erase dependency.
What this does: Stores the flight record locally so loss of radio does not lose the data. Connects to: Flight MCU quad-SPI -> 256 MiB NOR. Its supply switch and signal switches let the flight MCU turn the memory off without powering it through data pins.

Schematic: 10-test-points.kicad_sch, Test points / key nets

Parts:
TP1, TP47: GND; TestPoint_Keystone_5010-5014_Multipurpose; MPN 5011; LCSC C238127
TP4: SUPERVISOR_WDI; TestPoint_Pad_D1.0mm
TP6: ADC_PYRO1_CONTINUITY; TestPoint_Pad_D1.0mm
TP7: ADC_PYRO3_CONTINUITY; TestPoint_Pad_D1.0mm
TP11: ADC_PYRO2_CONTINUITY; TestPoint_Pad_D1.0mm
TP15: GNSS_PPS; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
TP20: USB_VBUS; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
TP21: STAGING_ARM_SENSE; TestPoint_Pad_D1.0mm
TP22: RECOVERY_ARM_SENSE; TestPoint_Pad_D1.0mm
TP26: COMMS_LDO_PG; TestPoint_Pad_D1.0mm
TP28: FC_POWER_HOLD; TestPoint_Pad_D1.0mm
TP29: USB_LIMITED; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
TP30: BOOT_3V3; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
TP33: BRANCH_FAULT_N; TestPoint_Pad_D1.0mm
TP38: FLIGHT_LDO_PG; TestPoint_Pad_D1.0mm
TP40: EXT_3V3; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
TP44: BAT_SHDN_N; TestPoint_Pad_D1.0mm
TP45: BAT_SOURCE_FAULT_N; TestPoint_Pad_D1.0mm

Connections:
ADC_PYRO1_CONTINUITY: TP6.1 (1_1); also elsewhere on the board
ADC_PYRO2_CONTINUITY: TP11.1 (1_1); also elsewhere on the board
ADC_PYRO3_CONTINUITY: TP7.1 (1_1); also elsewhere on the board
BAT_SHDN_N: TP44.1 (1_1); also elsewhere on the board
BAT_SOURCE_FAULT_N: TP45.1 (1_1); also elsewhere on the board
BOOT_3V3: TP30.1 (1_1); also elsewhere on the board
BRANCH_FAULT_N: TP33.1 (1_1); also elsewhere on the board
COMMS_LDO_PG: TP26.1 (1_1); also elsewhere on the board
EXT_3V3: TP40.1 (1_1); also elsewhere on the board
FC_POWER_HOLD: TP28.1 (1_1); also elsewhere on the board
FLIGHT_LDO_PG: TP38.1 (1_1); also elsewhere on the board
GND: TP1.1 (1_1), TP47.1 (1_1); also elsewhere on the board
GNSS_PPS: TP15.1 (1_1); also elsewhere on the board
RECOVERY_ARM_SENSE: TP22.1 (1_1); also elsewhere on the board
STAGING_ARM_SENSE: TP21.1 (1_1); also elsewhere on the board
SUPERVISOR_WDI: TP4.1 (1_1); also elsewhere on the board
USB_LIMITED: TP29.1 (1_1); also elsewhere on the board
USB_VBUS: TP20.1 (1_1); also elsewhere on the board

Notes on the sheet:
PADS: PYRO DIAGNOSTICS
YELLOW LOOPS: RAILS, PPS
PADS: POWER STATUS
BLACK LOOPS: GND (FWD, AFT)
What this does: test points on key nets not served elsewhere, in three sizes (D-22Nov.9). Silkscreen: TP number only. Black Keystone 5011 loops on GND at the board edges; yellow Keystone 5194TR surface-mount loops where a probe stays clipped on (rails, GNSS PPS); 1.0 mm round pads for nets you only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
TEST POINTS / KEY NETS

Schematic: 03te-pressure.kicad_sch, TE pressure / independent I2C and power

Parts:
C3502: 1u 16V X7R; C_0603_1608Metric
C3504: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
R3501: 47R 1%; R_0402_1005Metric; MPN RC0402FR-0747RL; LCSC C137973
R3505, R3506: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
U3503: MS560702BA03-50; MPN MS560702BA03-50

Connections:
FLIGHT_3V3: R3501.1, R3505.1, R3506.1; also elsewhere on the board
GND: C3502.2, C3504.2, U3503.3, U3503.4 (GND_[4,5,3]), U3503.5; also elsewhere on the board
TE_3V3: C3502.1, C3504.1, R3501.2, U3503.1, U3503.2 (SUPPLY_[2,1])
TE_SCL: R3505.2, U3503.8 (SCLK); also elsewhere on the board
TE_SDA: R3506.2, U3503.7 (SDI/SDA); also elsewhere on the board

Notes on the sheet:
2 INDEPENDENT I2C
TE PRESSURE / INDEPENDENT I2C AND POWER
MS5607: 0x77, PS high, CSB low. Straps are shown by the actual grouped supply/ground pin numbers.
Two dissimilar pressure sensors, each behind its own supply link. Atmospheric validity and flight estimation are software / mission responsibilities.
What this does: Measures air pressure with the TE MS5607, independently of the Bosch sensor. Connects to: Its own flight-MCU I2C bus, address 0x77, supplied through R3501, a 47 ohm link from FLIGHT_3V3 (D-6.6, D-2Nov.3). Both pressure readings go to the estimator; neither proves full-envelope heigh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
1 SUPPLY LINK

Schematic: 06pyro2.kicad_sch, PYRO2 / recovery domain

Parts:
C6404: 100n 25V X7R; C_0603_1608Metric
Q6401: CSD17318Q2; MPN CSD17318Q2
R6402, R6403, R6405: 100k; R_0603_1608Metric
R6404: 100R; R_0603_1608Metric
R6410: 0R ENERGY LINK - DNP; R_0603_1608Metric; not fitted
R6414: 1.24k 1%; R_0603_1608Metric
U6404: TPS1H100BQPWPRQ1; MPN TPS1H100BQPWPRQ1

Connections:
FLIGHT_3V3: U6404.12 (DIAG_EN); also elsewhere on the board
GND: C6404.2, Q6401.4 (GND_[4,7]), Q6401.7, R6402.2, R6403.2, R6405.2, R6414.2, U6404.2 (GND_[2,15]), U6404.15; also elsewhere on the board
OUTPUT2_HIGH: U6404.5 (OUT_[5,6,7]), U6404.6, U6404.7; also elsewhere on the board
OUTPUT2_LOW: Q6401.1 (D/D_EP_[1,2,5,6,8]), Q6401.2, Q6401.5, Q6401.6, Q6401.8; also elsewhere on the board
PYRO2_CL: R6414.1, U6404.13 (CL)
PYRO2_ENERGY: C6404.1, R6410.2, U6404.8 (VS_[8,9,10]), U6404.9, U6404.10
PYRO2_FIRE: R6403.1, U6404.3 (IN); also elsewhere on the board
PYRO2_GATE: Q6401.3 (G), R6404.2, R6405.1
PYRO2_LS_SELECT: R6402.1, R6404.1; also elsewhere on the board
RECOVERY_ARMED_VBAT: R6410.1; also elsewhere on the board

Notes on the sheet:
This is not an operable energetic channel. Populate only after load and inhibit review.
Igniter values open: energy link R6410 stays DNP. R6414 1.24k sets the switch limit near 2.0 A; pulse length is set in firmware (D-6.2).
PYRO2 / RECOVERY DOMAIN
CS can reach 4.9 V: never connect it directly to the 3.3 V ADC. Analog closure on next sheet.
1 HIGH-SIDE REQUEST: PYRO2_FIRE DIRECT TO U6404 IN
3 INDEPENDENT LOW-SIDE SELECT / SWITCHED RETURN
What this does: Shows the two switched sides for recovery channel 2: PE9 drives the high side, PC8 the low side. Connects to: RECOVERY_ARMED_VBAT (06a) and the flight MCU -> J6601 load pair on 06b; current report -> 06c. Energy link remains DNP: do not connect an initiator.
2 HIGH-SIDE ENERGY SWITCH / CURRENT REPORT

Schematic: 04-comms-gnss-radio.kicad_sch, COMMS MCU / STM32H563VIT6 / non-Q LQFP100

Parts:
U401: STM32H563RIT6; LQFP-64_10x10mm_P0.5mm; MPN STM32H563RIT6

Connections:
CC_BAT_VALID: U401.10 (PC2); also elsewhere on the board
CC_BRANCH_FAULT_N: U401.9 (PC1); also elsewhere on the board
CC_COMMS_TO_FLIGHT: U401.29 (PB10); also elsewhere on the board
CC_FLIGHT_TO_COMMS: U401.52 (PC11); also elsewhere on the board
COMMS_3V3: U401.1 (VBAT), U401.19 (VDD), U401.32 (VDD), U401.48 (VDD), U401.64 (VDD); also elsewhere on the board
COMMS_BOOT0: U401.60 (BOOT0); also elsewhere on the board
COMMS_HSE_IN: U401.5 (PH0); also elsewhere on the board
COMMS_HSE_OUT: U401.6 (PH1); also elsewhere on the board
COMMS_NRST: U401.7 (NRST); also elsewhere on the board
COMMS_STATUS_LED: U401.8 (PC0); also elsewhere on the board
COMMS_SWCLK: U401.49 (PA14(JTCK); also elsewhere on the board
COMMS_SWDIO: U401.46 (PA13(JTMS); also elsewhere on the board
COMMS_SWO: U401.55 (PB3(JTDO); also elsewhere on the board
COMMS_VCAP: U401.30 (VCAP), U401.62 (VCAP); also elsewhere on the board
COMMS_VDDA: U401.13 (VDDA); also elsewhere on the board
GND: U401.12 (VSSA), U401.18 (VSS), U401.31 (VSS), U401.47 (VSS), U401.63 (VSS); also elsewhere on the board
GNSS_PPS: U401.14 (PA0); also elsewhere on the board
GNSS_RESET_N: U401.17 (PA3); also elsewhere on the board
GNSS_RX: U401.36 (PB15); also elsewhere on the board
GNSS_TX: U401.42 (PA9); also elsewhere on the board
LORA_BUSY: U401.20 (PA4); also elsewhere on the board
LORA_DIO1: U401.26 (PB0); also elsewhere on the board
LORA_MISO: U401.22 (PA6); also elsewhere on the board
LORA_MOSI: U401.23 (PA7); also elsewhere on the board
LORA_NCS: U401.33 (PB12); also elsewhere on the board
LORA_RESET_N: U401.28 (PB2); also elsewhere on the board
LORA_SCK: U401.21 (PA5); also elsewhere on the board
USB_D+: U401.45 (PA12); also elsewhere on the board
USB_D-: U401.44 (PA11); also elsewhere on the board
USB_VBUS_PRESENT: U401.15 (PA1); also elsewhere on the board

Notes on the sheet:
PC3 / PC4: LORA_RXEN / LORA_TXEN reservations, MCU-only, no external connection (64-pad map); firmware holds them low or analog.
Allocation: the 64-pad map (proposed-comms-pinout.csv). Link to flight: USART3, PC10 TX / PC11 RX, AF7. ADC_ labels are scaled physical inputs, never raw battery rails. VCAP pins share their own node; never tied to 3.3 V. VBAT is the backup-domain pin, supplied by this MCU domain. SWD and oscillato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
What this does: Handles radio, GNSS and USB service so those tasks cannot monopolise the flight MCU. Connects to: UART link to flight: 04b. USB: 04c. GNSS: 04d. Radio: 04e/04f. Local supplies/clocks: 04a; reset/debug: 02comms-reset-debug.
Support, clock, reset and probe circuitry on the next sheet. Global labels connect sheets; named *_ISO nets are separate conductors on opposite sides of a powered-off-safe boundary. Firmware and hardware qualification remain with the team.
COMMS MCU / STM32H563RIT6 / LQFP64

Schematic: 02a-flight-support.kicad_sch, FLIGHT MCU / supplies, clocks and service

Parts:
C201, C202, C203, C204, C205, C207, C208, C212, C214: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
C206: 4.7u 16V X7R; C_0603_1608Metric
C209, C210, C220: 2.2u 10V X7R; C_0603_1608Metric
C211, C213: 1u 16V X7R; C_0603_1608Metric
C215, C216: 15p C0G provisional; C_0402_1005Metric; MPN 0402CG150J500NT; LCSC C1548
C217, C218: 9.1p C0G provisional; C_0402_1005Metric; MPN CC0402BRNPO9BN9R1; LCSC C526972
C219: 100u 6.3V X5R; C_1206_3216Metric
D201, D202: BAT54T1G; D_SOD-123; MPN BAT54T1G
R201: 0R; R_0603_1608Metric
R202: 470k; R_0402_1005Metric; MPN FRC0402F4703TS; LCSC C2906871
R203: 330R; R_0603_1608Metric
R204: 1k; R_0402_1005Metric; MPN 0402WGF1001TCE; LCSC C11702
R205: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
TP12: TP_PA9; TestPoint_Pad_D1.0mm
TP13: TP_PA12; TestPoint_Pad_D1.0mm
TP14: TP_PA11; TestPoint_Pad_D1.0mm
TP18: RESET_MEMORY; TestPoint_Pad_D1.0mm
TP19: TP_STROBE; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
Y201: ECS-160-10-36Q-ES-TR; MPN ECS-160-10-36Q-ES-TR
Y202: ABS07-32.768KHZ-7-T; MPN ABS07-32.768KHZ-7-T

Connections:
/02a-flight-support/TP_STROBE_PAD: R203.2, R205.1, TP19.1 (1_1)
FLIGHT_3V3: C201.1, C202.1, C203.1, C204.1, C205.1, C206.1, C208.1, D201.2 (A), R201.1, R202.1; also elsewhere on the board
FLIGHT_HSE_IN: C215.1, Y201.1 (XTAL); also elsewhere on the board
FLIGHT_HSE_OUT: C216.1, Y201.3 (XTAL); also elsewhere on the board
FLIGHT_LSE_IN: C217.1, Y202.1 (XTAL); also elsewhere on the board
FLIGHT_LSE_OUT: C218.1, Y202.2 (XTAL); also elsewhere on the board
FLIGHT_MR_N: R204.2; also elsewhere on the board
FLIGHT_VBAT: C207.1, C219.1, D201.1 (K); also elsewhere on the board
FLIGHT_VCAP: C209.1, C210.1; also elsewhere on the board
FLIGHT_VDDA: C211.1, C212.1, C213.1, C214.1, R201.2; also elsewhere on the board
GND: C201.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, R205.2, Y201.2 (CASE_GND), Y201.4 (CASE_GND); also elsewhere on the board
unnamed: D202.1 (K), R204.1
RESET_MEMORY: C220.1, D202.2 (A), R202.2, TP18.1 (1_1); also elsewhere on the board
TP_PA9: TP12.1 (1_1); also elsewhere on the board
TP_PA11: TP14.1 (1_1); also elsewhere on the board
TP_PA12: TP13.1 (1_1); also elsewhere on the board
TP_STROBE: R203.1; also elsewhere on the board

Notes on the sheet:
Y202 / ABS07-32.768KHZ-7-T
FLIGHT_VBAT / BACKUP-DOMAIN FEED
PB0 strobe to TP19 through R203; R205 holds it low at reset. PC6, PC7 and PD10 are spare pads: inputs with pull-downs in firmware. PC7 never drives: it neighbours PC8, channel 2's low side (D-19Nov.3).
Y201 / ECS-160-10-36Q-ES-TR
FLIGHT_VDDA / LOCAL BYPASS
RESET_MEMORY / WATCHDOG-RESET MEMORY
BAT54-class Schottky, so VBAT never back-feeds FLIGHT_3V3. C219 holds the backup domain (RTC, backup registers) through supply dips (D-6.4).
TEST POINTS / TIMING STROBE LOOP AND SPARE PADS
Digital bypass, VCAP and VDDA remain different electrical domains. Crystal load capacitances are provisional, not measured startup margins.
What this does: Gives the flight MCU stable local supplies, its two clock sources, the backup-domain feed, the watchdog-reset memory, the timing strobe and the spare test pads. Connects to: FLIGHT_3V3 -> U201 on 02-flight-mcu; FLIGHT_MR_N from the watchdog on 02flight-reset-debug. Main 16 MHz clock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
FLIGHT_VCAP / LOCAL BYPASS
FLIGHT_3V3 / LOCAL BYPASS
A watchdog reset (FLIGHT_MR_N low) empties C220 through D202 and R204 in a few ms; R202 refills it in about a second, so PA3 reads low just after a watchdog reset. Values confirmed on the bench (D-19Nov.3).
FLIGHT MCU / SUPPLIES, CLOCKS AND SERVICE

Schematic: 03bmp-pressure.kicad_sch, BMP pressure / independent I2C and power

Parts:
C3402: 1u 16V X7R; C_0603_1608Metric
C3404: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
R3401: 47R 1%; R_0402_1005Metric; MPN RC0402FR-0747RL; LCSC C137973
R3405, R3406: 4.7k; R_0402_1005Metric; MPN 0402WGF4701TCE; LCSC C25900
U3403: BMP390; MPN BMP390

Connections:
BMP_3V3: C3402.1, C3404.1, R3401.2, U3403.1 (SUPPLY_[1,6,10]), U3403.6, U3403.10
BMP_SCL: R3405.2, U3403.2 (SCK); also elsewhere on the board
BMP_SDA: R3406.2, U3403.4 (SDI); also elsewhere on the board
FLIGHT_3V3: R3401.1, R3405.1, R3406.1; also elsewhere on the board
GND: C3402.2, C3404.2, U3403.3 (GND_[3,5,8,9]), U3403.5, U3403.8, U3403.9; also elsewhere on the board

Notes on the sheet:
What this does: Measures air pressure with the Bosch BMP390, one of the two dissimilar pressure sensors. Connects to: Its own flight-MCU I2C bus, address 0x76, supplied through R3401, a 47 ohm link from FLIGHT_3V3 (D-6.6, D-2Nov.3). Pressure is not a valid height measurement across the whole space-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
BMP390: 0x76, CSB high, SDO low. Straps are shown by the actual grouped supply/ground pin numbers.
Two dissimilar pressure sensors, each behind its own supply link. Atmospheric validity and flight estimation are software / mission responsibilities.
BMP PRESSURE / INDEPENDENT I2C AND POWER
2 INDEPENDENT I2C
1 SUPPLY LINK

Schematic: 04b-uart-boundary.kicad_sch, Flight-comms boundary / UART

Parts:
C4301, C4302, C4303, C4304, C4305, C4306: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
R4301, R4302, R4303: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
U4301: TXU0202DCUR; MPN TXU0202DCUR
U4302: TXU0101DCKR; MPN TXU0101DCKR
U4303: TXU0304PWR; MPN TXU0304PWR

Connections:
BAT_VALID: U4303.2 (A1); also elsewhere on the board
BOOT_3V3: C4305.1, U4303.1 (SUPPLY_[1,8]), U4303.8; also elsewhere on the board
CC_BAT_VALID: U4303.13 (B1Y); also elsewhere on the board
CC_COMMS_TO_FLIGHT: U4301.1 (B2); also elsewhere on the board
CC_FLIGHT_TO_COMMS: R4303.2, U4301.8 (B1Y); also elsewhere on the board
COMMS_3V3: C4302.1, C4304.1, C4306.1, R4303.1, U4301.7 (VCCB), U4302.6 (VCCB), U4303.14 (VCCB); also elsewhere on the board
COMMS_MR_N: U4302.4 (BY); also elsewhere on the board
COMMS_RESET_REQUEST: R4301.2, U4302.3 (A); also elsewhere on the board
COMMS_TO_FLIGHT: R4302.2, U4301.4 (A2Y); also elsewhere on the board
FLIGHT_3V3: C4301.1, C4303.1, R4301.1, R4302.1, U4301.3 (SUPPLY_[3,6]), U4301.6, U4302.1 (SUPPLY_[1,5]), U4302.5; also elsewhere on the board
FLIGHT_TO_COMMS: U4301.5 (A1); also elsewhere on the board
GND: C4301.2, C4302.2, C4303.2, C4304.2, C4305.2, C4306.2, U4301.2 (GND), U4302.2 (GND), U4303.4 (GND_[4,7]), U4303.7, U4303.10 (B4); also elsewhere on the board
USB_PRESENT: U4303.3 (A2); also elsewhere on the board
USB_VBUS_PRESENT: U4303.12 (B2Y); also elsewhere on the board

Notes on the sheet:
RESET REQUEST: flight requests a communications reset through MR.
FLIGHT-COMMS BOUNDARY / UART
The reset translator drives MR, not the open-drain NRST net. Firmware policy remains with Anav.
Flight UART starts at 2 Mbaud. 8 Mbaud is negotiated only for disarmed extraction.
UART: one signal in each direction.
What this does: Passes messages and a few control/status signals between the processors without feeding power through an off MCU. Connects to: U201 flight <-> U401 comms. Includes the flight-requested comms reset, battery-valid and USB-present status, not just UART data.
POWER STATUS: two indications out. Channel 4 is unused: USB_CONFIG_OK is dropped (D-21Nov.14).

Schematic: 06f-continuity-isolation.kicad_sch, Continuity ADC / powered-off-safe crossing

Parts:
C6901: 100n 16V X7R; C_0603_1608Metric
R6917, R6927, R6937: 22.1k 0.1%; R_0603_1608Metric
U6901: TMUX1511PWR; MPN TMUX1511PWR

Connections:
ADC_PYRO1_CONTINUITY: U6901.3 (D1); also elsewhere on the board
ADC_PYRO2_CONTINUITY: U6901.6 (D2); also elsewhere on the board
ADC_PYRO3_CONTINUITY: U6901.8 (D3); also elsewhere on the board
FLIGHT_3V3: C6901.1, U6901.1 (SUPPLY_[1,4,10,14]), U6901.4, U6901.10, U6901.14; also elsewhere on the board
GND: C6901.2, U6901.7 (GND_[7,13]), U6901.13; also elsewhere on the board
PYRO1_CONT_MID: R6917.1; also elsewhere on the board
PYRO1_CONT_SCALED: R6917.2, U6901.2 (S1); also elsewhere on the board
PYRO2_CONT_MID: R6927.1; also elsewhere on the board
PYRO2_CONT_SCALED: R6927.2, U6901.5 (S2); also elsewhere on the board
PYRO3_CONT_MID: R6937.1; also elsewhere on the board
PYRO3_CONT_SCALED: R6937.2, U6901.9 (S3); also elsewhere on the board

Notes on the sheet:
ADC settling, partial-rail leakage, clamps and single-fault no-fire review remain open.
Return attenuation = 10/(22.1+22.1+10), also loaded by the 100k ADC default resistor.
CONTINUITY ADC / POWERED-OFF-SAFE CROSSING
What this does: Finishes the continuity voltage dividers and disconnects them from an unpowered flight ADC. Connects to: Return measurements on 06e -> analog switches -> flight ADC, with default pulls on 06c. No continuity result is a physical disarm proof.
Split top resistance bounds an individual resistor short at the declared 2S voltage.
Remove the default load or calibrate its effect before claiming continuity thresholds.

Schematic: 06b-output-harness.kicad_sch, Output harnesses

Parts:
C6601, C6602, C6603, C6604, C6605, C6606: 1n 50V C0G; C_0603_1608Metric
J6601: 430450600; MPN 430450600

Connections:
GND: C6601.2, C6602.2, C6603.2, C6604.2, C6605.2, C6606.2; also elsewhere on the board
OUTPUT1_HIGH: C6601.1, J6601.1; also elsewhere on the board
OUTPUT1_LOW: C6602.1, J6601.4; also elsewhere on the board
OUTPUT2_HIGH: C6603.1, J6601.2; also elsewhere on the board
OUTPUT2_LOW: C6604.1, J6601.5; also elsewhere on the board
OUTPUT3_HIGH: C6605.1, J6601.3; also elsewhere on the board
OUTPUT3_LOW: C6606.1, J6601.6; also elsewhere on the board

Notes on the sheet:
1/4 = channel 1; 2/5 = channel 2; 3/6 = channel 3.
Servos removed (D-19Nov.2): J6602, its PWM and enable resistors and sheet 06d are gone.
OUTPUT HARNESS
Three isolated energetic load pairs; LOW is a switched return, not a chassis contact.
High + low both go to the remote removable e-match connection.
1 THREE ENERGETIC LOAD PAIRS / J6601
C6601-C6606: 1 nF C0G from each output to GND at J6601 (D-22Nov.20). RF picked up on the e-match leads returns here, not through the switches.
Karman recorder population: no output source/harness; independent vehicle recovery required.
What this does: Defines the physical connector contacts for three energetic loads. Connects to: Three channel sheets -> J6601. Both wires of each energetic load return here; LOW is a switched return, not ground.

Schematic: 02flight-reset-debug.kicad_sch, FLIGHT / supervised reset / independent SWD

Parts:
C2301, C2302, C2303: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
J2301: TC2030-NL-FP; MPN TC2030-NL-FP
R2301, R2302, R2303, R2310: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R2311: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
TP16: GND; TestPoint_Keystone_5010-5014_Multipurpose; MPN 5011; LCSC C238127
TP17: FLIGHT_BOOT0; TestPoint_Pad_D1.0mm
U2301: TPS3808G33DBVR; MPN TPS3808G33DBVR
U2302: TPS3430WDRCR; MPN TPS3430WDRCR

Connections:
FLIGHT_3V3: C2301.1, C2302.1, J2301.1, R2301.1, R2302.1, R2310.1, U2301.5 (SUPPLY_[5,6]), U2301.6, U2302.1, U2302.10 (SUPPLY_[10,1]); also elsewhere on the board
FLIGHT_BOOT0: R2303.1, TP17.1 (1_1); also elsewhere on the board
FLIGHT_MR_N: R2302.2, U2301.3 (~MR), U2302.8 (~WDO); also elsewhere on the board
FLIGHT_NRST: C2303.1, J2301.3, R2301.2, U2301.1 (~RESET); also elsewhere on the board
FLIGHT_SWCLK: J2301.4; also elsewhere on the board
FLIGHT_SWDIO: J2301.2; also elsewhere on the board
GND: C2301.2, C2302.2, C2303.2, J2301.5, R2303.2, R2311.2, TP16.1 (1_1), U2301.2 (GND), U2302.3, U2302.5, U2302.6, U2302.11 (GND_[11,3,6,5]); also elsewhere on the board
SUPERVISOR_WDI: R2311.1, U2302.7 (WDI); also elsewhere on the board
WATCHDOG_CWD: R2310.2, U2302.2 (CWD)

Notes on the sheet:
What this does: Holds the flight MCU in reset when its supply is unsuitable, and gives us a dedicated programming/debug connection. Connects to: Flight rail + external watchdog -> supervisor -> U201 reset. Tag-Connect goes to U201 SWD; reset also inhibits output authority.
MR and NRST are different nets. Supervisor output resets the MCU; external watchdog requests supervisor reset through MR.
FLIGHT / SUPERVISED RESET / INDEPENDENT SWD
Boot pull-down and Tag-Connect pins are visible. Firmware ownership, MCU allocations, watchdog timing and reset policy are unchanged.

Schematic: 04d-gnss.kicad_sch, GNSS / MAX-M10S / external passive antenna

Parts:
C4501, C4503, C4505, C4506: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
C4504: 10u 16V X7R; C_0805_2012Metric; MPN CL21B106KOQNNNE
D4501: PESD5V0F1BL,315; D_SOD-882; MPN PESD5V0F1BL,315
J4501: 132134; SMA_Amphenol_132134_Vertical; MPN 132134
R4504: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
U4504: MAX-M10S-00B; MPN MAX-M10S-00B

Connections:
COMMS_3V3: C4501.1, C4503.1, C4504.1, C4505.1, C4506.1, R4504.1, U4504.7 (VCC_IO), U4504.8 (VCC); also elsewhere on the board
GND: C4501.2, C4503.2, C4504.2, C4505.2, C4506.2, D4501.2 (A2), J4501.2 (Ext), U4504.1 (GND), U4504.10 (GND), U4504.12 (GND); also elsewhere on the board
GNSS_PPS: U4504.4 (TIMEPULSE); also elsewhere on the board
GNSS_RESET_N: R4504.2, U4504.9 (~RESET); also elsewhere on the board
GNSS_RF: D4501.1 (A1), J4501.1 (In), U4504.11 (RF_IN)
GNSS_RX: U4504.2 (TXD); also elsewhere on the board
GNSS_TX: U4504.3 (RXD); also elsewhere on the board

Notes on the sheet:
HARDWARE POWER PERMISSION AND LOAD SWITCH
STARTUP: TIMEPULSE4 / SAFEBOOT18 are internally coupled through 1 kohm. Leave SAFEBOOT unloaded; no PPS pull-down at startup.
What this does: Gets satellite position and time from an antenna mounted outside the carbon airframe. Connects to: Passive antenna/SMA -> MAX-M10S -> comms UART, pulse-per-second and reset. Power needs both battery-valid and the comms request. No antenna bias or ANT_CHECK.
Same U4504 symbol UUID and hierarchy path. D4501 is Nexperia PESD5V0F1BL (SOD882), placeable by Economic PCBA (D-22Nov.8).
RECEIVER / LOCAL BYPASS / PASSIVE RF FEED
POWERED-OFF SIGNAL BOUNDARY
GNSS power = requested AND battery valid; USB-only service leaves GNSS unpowered. QOD resistor discharges the switched rail.
50-ohm RF route, short ESD return at SMA. Antenna/coax loss, RF layout, receiver survival and installed ESD tests remain open.
GNSS / EXTERNAL PASSIVE ANTENNA
No backup source: V_BCKP open. VIO_SEL open for 3.3 V I/O. VCC_RF/LNA_EN unused. SAFEBOOT, EXTINT and I2C unused.

Schematic: 06-outputs.kicad_sch, Output authority

Parts:
C6001: 100n 16V X7R; C_0603_1608Metric
R6001: 100k; R_0603_1608Metric
R6005: 1k; R_0603_1608Metric
U6001: SN74LVC1G74DCUR; MPN SN74LVC1G74DCUR

Connections:
FLIGHT_3V3: C6001.1, U6001.7 (SUPPLY_[7,8]), U6001.8; also elsewhere on the board
FLIGHT_NRST: U6001.6 (~CLR); also elsewhere on the board
GND: C6001.2, R6001.2, U6001.4 (GND); also elsewhere on the board
NEW_FLIGHT_CLEAR_REQUEST: R6001.1, U6001.1 (CLK); also elsewhere on the board
unnamed: R6005.1, U6001.3 (~Q)
STAGE_ARM_INVALID: U6001.2 (D); also elsewhere on the board
STAGE_ELIGIBLE: U6001.5 (Q); also elsewhere on the board
STAGE_INHIBIT_LATCHED: R6005.2; also elsewhere on the board

Notes on the sheet:
A low arm sense is not proof that the physical energy break is open.
1 NEW-FLIGHT EDGE / RESET-TO-INHIBIT LATCH
What this does: Holds the staging channel inhibited after any flight reset or power-up, until the flight MCU clocks the latch with staging disarmed (D-7.2). Connects to: FLIGHT_NRST, PD15 request and STAGE_ARM_INVALID (06a) -> STAGE_ELIGIBLE to 06pyro3; STAGE_INHIBIT_LATCHED -> PE14. This logic doe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
D = STAGE_ARM_INVALID (U6103 OUTB, 06a): the latch can only be set while staging is disarmed.
OUTPUT AUTHORITY / STAGING RESET LATCH
All internal/debug/software reset classes must clear this latch; target NRST proof remains open.
Q-bar -> R6005 1k -> PE14. Arm feeds and arm sense: 06a. Channel 3 fires only through U6502 (PYRO3_FIRE AND STAGE_ELIGIBLE), 06pyro3.
CLOCK is the request edge. D qualifies the edge; do not gate the clock.
CLK is the request edge directly. Disarm qualifies D, never gates CLK. Q-bar = inhibited.

Schematic: 05-can.kicad_sch, Vehicle CAN / bounded optional branch

Parts:
C501, C503, C504, C505, C506, C507, C508, C509, C510: 100n 16V X7R; C_0402_1005Metric; MPN CL05B104KB54PNC; LCSC C307331
C502: 1u 16V X7R; C_0603_1608Metric
D501, D502: ESD2CAN24DBZRQ1; SOT-23; MPN ESD2CAN24DBZRQ1
F501, F502: 0R link; Fuse_1206_3216Metric
J501, J502: G125-MS10605M2P; MPN G125-MS10605M2P
R501: 0R; R_0603_1608Metric
R502: 210k 1%; R_0603_1608Metric
R503: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R504, R505, R506, R507, R508, R511, R512, R513, R514: 47k; R_0402_1005Metric; MPN 0402WGF4702TCE; LCSC C25792
R509: 10k; R_0402_1005Metric; MPN 0402WGF1002TCE; LCSC C25744
R510, R515: 120R 1% 0.25W; R_0805_2012Metric
R516, R517: 0R; R_0805_2012Metric
TP34: CAN_3V3; TestPoint_Keystone_5190TR_ColorKeyed; MPN 5194TR; LCSC C22388408
U501: TPS2553DBVR-1; MPN TPS2553DBVR-1
U502, U504: TXU0304PWR; MPN TXU0304PWR
U503, U505: TCAN3413DRBR; MPN TCAN3413DRBR

Connections:
/05-can/CAN2_REF: J502.3, R517.1
/05-can/CAN_REF: J501.3, R516.1
BRANCH_FAULT_N: U501.4 (~FAULT); also elsewhere on the board
CAN2+: D502.1 (IO1), J502.1, R515.1, U505.7 (CANH)
CAN2-: D502.2 (IO2), J502.2, R515.2, U505.6 (CANL)
CAN2_RX: R512.2, U504.5 (A4Y); also elsewhere on the board
CAN2_RX_ISO: U504.10 (B4), U505.4 (RXD)
CAN2_STB_ISO: R514.2, U504.12 (B2Y), U505.8 (STB)
CAN2_TX: R511.2, U504.2 (A1); also elsewhere on the board
CAN2_TX_ISO: R513.2, U504.13 (B1Y), U505.1 (TXD)
CAN+: D501.1 (IO1), J501.1, R510.1, U503.7 (CANH)
CAN-: D501.2 (IO2), J501.2, R510.2, U503.6 (CANL)
CAN_3V3: C502.1, C504.1, C505.1, C506.1, C508.1, C509.1, C510.1, R501.2, R507.1, R508.1, R509.1, R513.1, R514.1, TP34.1 (1_1), U502.14 (VCCB), U503.3 (VCC), U503.5 (VIO), U504.14 (VCCB), U505.3 (VCC), U505.5 (VIO)
CAN_ILIM: R502.1, U501.5 (ILIM)
CAN_POWER_EN: R503.1, U501.3 (EN), U502.8 (OE), U504.8 (OE); also elsewhere on the board
CAN_RX: R506.2, U502.5 (A4Y); also elsewhere on the board
CAN_RX_ISO: U502.10 (B4), U503.4 (RXD)
CAN_STB: R505.2, U502.3 (A2), U504.3 (A2); also elsewhere on the board
CAN_STB_ISO: R508.2, U502.12 (B2Y), U503.8 (STB)
CAN_SWITCH_OUT: R501.1, U501.6 (OUT)
CAN_TX: R504.2, U502.2 (A1); also elsewhere on the board
CAN_TX_ISO: R507.2, U502.13 (B1Y), U503.1 (TXD)
FLIGHT_3V3: C501.1, C503.1, C507.1, R504.1, R505.1, R506.1, R511.1, R512.1, U501.1 (IN), U502.1 (VCCA), U504.1 (VCCA); also elsewhere on the board
GND: C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, D501.3 (GND), D502.3 (GND), F501.2, F502.2, R502.2, R503.2, R509.2, U501.2 (GND), U502.4 (A3), U502.7 (GND), U503.2 (GND), U503.9 (EP_GND), U504.4 (A3), U504.7 (GND), U505.2 (GND), U505.9 (EP_GND); also elsewhere on the board
unnamed: F501.1, R516.2
unnamed: F502.1, R517.2

Notes on the sheet:
BUS 1 / FDCAN1 / PROPULSION CONTROLLER (FAJITA) / J501
120 ohms is the fixed endpoint termination. Keep CAN H/L twisted up to the connector; the third conductor is the reference return. Each reference contact reaches GND only through R516 / F501 (bus 1) or R517 / F502 (bus 2): footprints for a resistor and a resettable fuse, 0R until the bench sets val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
CAN / SWITCHED POWER / LOGIC BOUNDARIES / TWO BUSES
The switched rail and TXU stop signal back-powering. Common source/ground faults remain; first-PCBA cable/fault tests are still required.
BUS 2 / FDCAN2 / ACTIVE BOARD / J502
What this does: Connects the flight MCU to the propulsion controller (bus 1, FDCAN1, J501) and to the active board (bus 2, FDCAN2, J502), each over its own wired CAN pair. Connects to: Flight CAN pins -> switched transceivers -> Harwin Gecko-SL H / L / reference. Each link is two nodes at 500 kbit/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

Schematic: 06e-continuity.kicad_sch, Continuity topology

Parts:
R6911, R6912, R6913, R6914, R6921, R6922, R6923, R6924, R6931, R6932, R6933, R6934: 3.9k 1%; R_0603_1608Metric
R6915, R6925, R6935: 22.1k 0.1%; R_0603_1608Metric
R6916, R6926, R6936: 10k 0.1%; R_0603_1608Metric

Connections:
FLIGHT_3V3: R6911.1, R6921.1, R6931.1; also elsewhere on the board
GND: R6914.2, R6916.2, R6924.2, R6926.2, R6934.2, R6936.2; also elsewhere on the board
OUTPUT1_HIGH: R6912.2; also elsewhere on the board
OUTPUT1_LOW: R6913.1, R6915.1; also elsewhere on the board
OUTPUT2_HIGH: R6922.2; also elsewhere on the board
OUTPUT2_LOW: R6923.1, R6925.1; also elsewhere on the board
OUTPUT3_HIGH: R6932.2; also elsewhere on the board
OUTPUT3_LOW: R6933.1, R6935.1; also elsewhere on the board
PYRO1_CONT_MID: R6915.2; also elsewhere on the board
PYRO1_CONT_SCALED: R6916.1; also elsewhere on the board
PYRO1_RETURN_MID: R6913.2, R6914.1
PYRO1_TEST_MID: R6911.2, R6912.1
PYRO2_CONT_MID: R6925.2; also elsewhere on the board
PYRO2_CONT_SCALED: R6926.1; also elsewhere on the board
PYRO2_RETURN_MID: R6923.2, R6924.1
PYRO2_TEST_MID: R6921.2, R6922.1
PYRO3_CONT_MID: R6935.2; also elsewhere on the board
PYRO3_CONT_SCALED: R6936.1; also elsewhere on the board
PYRO3_RETURN_MID: R6933.2, R6934.1
PYRO3_TEST_MID: R6931.2, R6932.1

Notes on the sheet:
Test and return resistors 3.9k 1% 0603, fitted (D-2Nov.14): under a tenth of the no-fire current of any igniter rated 25 mA or more.
R6917 on sheet 06f completes MID -> SCALED; divider lower leg is at right.
CHANNEL 3 / CONTINUITY: 3.9k TEST AND RETURN
What this does: Shows the proposed low-current check for whether each external load is connected. Connects to: External load pairs -> test/return resistors -> divider on 06f -> flight ADC. Test and return resistors are 3.9k, safe for an igniter with a no-fire current of 25 mA or more.
R6927 on sheet 06f completes MID -> SCALED; divider lower leg is at right.
R6937 on sheet 06f completes MID -> SCALED; divider lower leg is at right.
CONTINUITY TOPOLOGY
Low-return short is indistinguishable from an open load in this topology: report ambiguity.
CHANNEL 2 / CONTINUITY: 3.9k TEST AND RETURN
Connected load raises its switched-return node through the test resistors; an open load does not.
CHANNEL 1 / CONTINUITY: 3.9k TEST AND RETURN
Values require exact no-fire/current/time limits with ANY ONE limiting resistor shorted.

Schematic: 06c-output-diagnostics.kicad_sch, Output ADC boundary

Parts:
R6714, R6724, R6734: 100k; R_0603_1608Metric

Connections:
ADC_PYRO1_CONTINUITY: R6714.1; also elsewhere on the board
ADC_PYRO2_CONTINUITY: R6724.1; also elsewhere on the board
ADC_PYRO3_CONTINUITY: R6734.1; also elsewhere on the board
GND: R6714.2, R6724.2, R6734.2; also elsewhere on the board

Notes on the sheet:
CS: K=2000 nominal, 750R burden; divider 47/94.4.
CHANNEL 3
OUTPUT ADC BOUNDARY
Divider loading/ADC behavior require calibration.
CHANNEL 1
What this does: Reduces and filters each channel's current-report signal before the flight MCU measures it. Connects to: Three high-side switches -> resistor/filter networks -> flight ADC. The separate continuity inputs only have default pulls here; their test circuit is on 06e/06f.
CHANNEL 2
Continuity injection fitted (06e, 3.9k); zero is not safe-arm proof.
4.9 V -> 2.44 V; one top resistor short -> 3.26 V.
CONTINUITY ADC DEFAULTS / NOT CURRENT BURDENS

Schematic: 02-flight-mcu.kicad_sch, FLIGHT MCU / STM32H563VIT6 / non-Q LQFP100

Parts:
U201: STM32H563VIT6; MPN STM32H563VIT6

Connections:
ADC_FLIGHT_3V3: U201.35 (PB0); also elsewhere on the board
ADC_PYRO1_CONTINUITY: U201.18 (PC3); also elsewhere on the board
ADC_PYRO2_CONTINUITY: U201.24 (PA1); also elsewhere on the board
ADC_PYRO3_CONTINUITY: U201.23 (PA0); also elsewhere on the board
ADC_PYRO_RAIL: U201.25 (PA2); also elsewhere on the board
ADC_VEHICLE_VBAT: U201.34 (PC5); also elsewhere on the board
BMP_SCL: U201.92 (PB6); also elsewhere on the board
BMP_SDA: U201.93 (PB7); also elsewhere on the board
BRANCH_FAULT_N: U201.4 (PE5); also elsewhere on the board
BUZZER_DRIVE: U201.86 (PD5); also elsewhere on the board
CAN2_RX: U201.91 (PB5); also elsewhere on the board
CAN2_TX: U201.69 (PA10); also elsewhere on the board
CAN_POWER_EN: U201.57 (PD10); also elsewhere on the board
CAN_RX: U201.81 (PD0); also elsewhere on the board
CAN_STB: U201.62 (PD15); also elsewhere on the board
CAN_TX: U201.82 (PD1); also elsewhere on the board
CHURRO_RETURN_EN: U201.43 (PE12); also elsewhere on the board
CHURRO_SCL: U201.95 (PB8); also elsewhere on the board
CHURRO_SDA: U201.96 (PB9); also elsewhere on the board
COMMS_RESET_REQUEST: U201.37 (PB2); also elsewhere on the board
COMMS_TO_FLIGHT: U201.56 (PD9); also elsewhere on the board
FC_POWER_HOLD: U201.45 (PE14); also elsewhere on the board
FLIGHT_3V3: U201.11 (VDD), U201.28 (VDD), U201.50 (VDD), U201.73 (VDDUSB), U201.75 (VDD), U201.100 (VDD); also elsewhere on the board
FLIGHT_BOOT0: U201.94 (BOOT0); also elsewhere on the board
FLIGHT_COMMS_EN: U201.63 (PC6); also elsewhere on the board
FLIGHT_HSE_IN: U201.12 (PH0); also elsewhere on the board
FLIGHT_HSE_OUT: U201.13 (PH1); also elsewhere on the board
FLIGHT_LSE_IN: U201.8 (PC14); also elsewhere on the board
FLIGHT_LSE_OUT: U201.9 (PC15); also elsewhere on the board
FLIGHT_NRST: U201.14 (NRST); also elsewhere on the board
FLIGHT_STATUS_LED1: U201.51 (PB12); also elsewhere on the board
FLIGHT_SWCLK: U201.76 (PA14(JTCK); also elsewhere on the board
FLIGHT_SWDIO: U201.72 (PA13(JTMS); also elsewhere on the board
FLIGHT_TO_COMMS: U201.55 (PD8); also elsewhere on the board
FLIGHT_VBAT: U201.6 (VBAT); also elsewhere on the board
FLIGHT_VCAP: U201.48 (VCAP), U201.98 (VCAP); also elsewhere on the board
FLIGHT_VDDA: U201.21 (VREF+), U201.22 (VDDA); also elsewhere on the board
GND: U201.10 (VSS), U201.19 (VSSA), U201.20 (VREF-), U201.27 (VSS), U201.49 (VSS), U201.74 (VSS), U201.99 (VSS); also elsewhere on the board
HG_INT1: U201.90 (PB4(NJTRST)); also elsewhere on the board
HG_MISO: U201.79 (PC11); also elsewhere on the board
HG_MOSI: U201.80 (PC12); also elsewhere on the board
HG_NCS: U201.83 (PD2); also elsewhere on the board
HG_SCK: U201.78 (PC10); also elsewhere on the board
MAG_INT: U201.84 (PD3); also elsewhere on the board
MAG_SCL: U201.67 (PA8); also elsewhere on the board
MAG_SDA: U201.66 (PC9); also elsewhere on the board
NEW_FLIGHT_CLEAR_REQUEST: U201.88 (PD7); also elsewhere on the board
NOR_CLK: U201.26 (PA3); also elsewhere on the board
NOR_IO0: U201.58 (PD11); also elsewhere on the board
NOR_IO1: U201.59 (PD12); also elsewhere on the board
NOR_IO2: U201.1 (PE2); also elsewhere on the board
NOR_IO3: U201.60 (PD13); also elsewhere on the board
NOR_NCS: U201.42 (PE11); also elsewhere on the board
NOR_RESET_REQUEST: U201.5 (PE6); also elsewhere on the board
PYRO1_FIRE: U201.38 (PE7); also elsewhere on the board
PYRO1_LS_SELECT: U201.33 (PC4); also elsewhere on the board
PYRO2_FIRE: U201.40 (PE9); also elsewhere on the board
PYRO2_LS_SELECT: U201.36 (PB1); also elsewhere on the board
PYRO3_FIRE: U201.46 (PE15); also elsewhere on the board
PYRO3_LS_SELECT: U201.85 (PD4); also elsewhere on the board
RECOVERY_ARM_SENSE: U201.44 (PE13); also elsewhere on the board
RESET_MEMORY: U201.29 (PA4); also elsewhere on the board
STAGE_INHIBIT_LATCHED: U201.97 (PE0); also elsewhere on the board
STAGING_ARM_SENSE: U201.87 (PD6); also elsewhere on the board
ST_DRDY: U201.64 (PC7); also elsewhere on the board
ST_MISO: U201.31 (PA6); also elsewhere on the board
ST_MOSI: U201.32 (PA7); also elsewhere on the board
ST_NCS: U201.61 (PD14); also elsewhere on the board
ST_SCK: U201.30 (PA5); also elsewhere on the board
SUPERVISOR_WDI: U201.3 (PE4); also elsewhere on the board
TDK_DRDY: U201.77 (PA15(JTDI)); also elsewhere on the board
TDK_MISO: U201.53 (PB14); also elsewhere on the board
TDK_MOSI: U201.54 (PB15); also elsewhere on the board
TDK_NCS: U201.65 (PC8); also elsewhere on the board
TDK_SCK: U201.52 (PB13); also elsewhere on the board
TE_SCL: U201.47 (PB10); also elsewhere on the board
TE_SDA: U201.89 (PB3(JTDO); also elsewhere on the board
TP_PA9: U201.68 (PA9); also elsewhere on the board
TP_PA11: U201.70 (PA11); also elsewhere on the board
TP_PA12: U201.71 (PA12); also elsewhere on the board
TP_STROBE: U201.41 (PE10); also elsewhere on the board

Notes on the sheet:
Support, clock, reset and probe circuitry on the next sheet. Global labels connect sheets; named *_ISO nets are separate conductors on opposite sides of a powered-off-safe boundary. Firmware and hardware qualification remain with the team.
Allocation: the 100-pad map as amended by the capture specification, 21 Nov 2026 (D-2Nov.1, D-2Nov.11, D-2Nov.18, D-5Nov.3, D-7.2, D-19Nov.2, D-19Nov.3). Pin names and directions: docs/firmware-interface.md. ADC_ labels are scaled physical inputs, never raw battery rails. VCAP pins share their own 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
What this does: Runs flight sensing, estimation, mission decisions, recording, outputs and both vehicle CAN buses. Connects to: Sensor/storage sheets 03*, outputs 06*, CAN 05, monitoring 07*/08, comms link 04b and the power hold on 01-power. Supplies/clocks/test pads: 02a. Reset/debug: 02flight-res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
FLIGHT MCU / STM32H563VIT6 / NON-Q LQFP100

Schematic: 06pyro1.kicad_sch, PYRO1 / recovery domain

Parts:
C6304: 100n 25V X7R; C_0603_1608Metric
Q6301: CSD17318Q2; MPN CSD17318Q2
R6302, R6303, R6305: 100k; R_0603_1608Metric
R6304: 100R; R_0603_1608Metric
R6310: 0R ENERGY LINK - DNP; R_0603_1608Metric; not fitted
R6314: 1.24k 1%; R_0603_1608Metric
U6304: TPS1H100BQPWPRQ1; MPN TPS1H100BQPWPRQ1

Connections:
FLIGHT_3V3: U6304.12 (DIAG_EN); also elsewhere on the board
GND: C6304.2, Q6301.4 (GND_[4,7]), Q6301.7, R6302.2, R6303.2, R6305.2, R6314.2, U6304.2 (GND_[2,15]), U6304.15; also elsewhere on the board
OUTPUT1_HIGH: U6304.5 (OUT_[5,6,7]), U6304.6, U6304.7; also elsewhere on the board
OUTPUT1_LOW: Q6301.1 (D/D_EP_[1,2,5,6,8]), Q6301.2, Q6301.5, Q6301.6, Q6301.8; also elsewhere on the board
PYRO1_CL: R6314.1, U6304.13 (CL)
PYRO1_ENERGY: C6304.1, R6310.2, U6304.8 (VS_[8,9,10]), U6304.9, U6304.10
PYRO1_FIRE: R6303.1, U6304.3 (IN); also elsewhere on the board
PYRO1_GATE: Q6301.3 (G), R6304.2, R6305.1
PYRO1_LS_SELECT: R6302.1, R6304.1; also elsewhere on the board
RECOVERY_ARMED_VBAT: R6310.1; also elsewhere on the board

Notes on the sheet:
2 HIGH-SIDE ENERGY SWITCH / CURRENT REPORT
1 HIGH-SIDE REQUEST: PYRO1_FIRE DIRECT TO U6304 IN
What this does: Shows the two switched sides for recovery channel 1: PE7 drives the high side, PA9 the low side. Connects to: RECOVERY_ARMED_VBAT (06a) and the flight MCU -> J6601 load pair on 06b; current report -> 06c. Energy link remains DNP: do not connect an initiator.
CS can reach 4.9 V: never connect it directly to the 3.3 V ADC. Analog closure on next sheet.
Igniter values open: energy link R6310 stays DNP. R6314 1.24k sets the switch limit near 2.0 A; pulse length is set in firmware (D-6.2).
3 INDEPENDENT LOW-SIDE SELECT / SWITCHED RETURN
This is not an operable energetic channel. Populate only after load and inhibit review.
PYRO1 / RECOVERY DOMAIN
